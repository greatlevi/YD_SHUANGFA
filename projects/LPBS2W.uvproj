# Keil uVision project LPBS2W.uvproj, settings and files
target LPBS2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPBS2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPBS2W.bin ./output/LPBS2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPBS2W.bin ./output/LPBS2W_UPGARDE.bin
  c flags: Optim=3 OneElfS=1
  c define: __KEIL_MDK__ __LPB100__ ZC_MODULE_VERSION=9 ZC_MODULE_TYPE=1
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.30/include/;..\sdk\1.30\cyassl\;..\sdk\1.30\include\lwip;..\src\AC\inc;..\src\aes;..\src\jdsmart;..\src\ZC\inc;..\src\ZC\inc\zc;..\src;..\src\ZC\inc\tropicssl
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c main.c zc_hf_adpter.c
    ../src/jdsmart/: cJSON.c common.c jdservice.c jdsmart.c jdudp.c ota.c
  group libs
    ../sdk/1.30/libs/: LPB100SSL.lib LPB100Kernel.lib
  group doc
    ../../: readme.txt
  group AC
    ../src/AC/src/: ac_api.c ac_hal.c
  group aes
    ../src/aes/: aes_cbc.c aes_core.c
  group ZC
    ../src/ZC/src/zc/: zc_bc.c zc_cloud_event.c zc_common.c zc_configuration.c zc_message_queue.c zc_protocol_controller.c zc_sec_engine.c zc_timer.c
    ../src/ZC/src/tropicssl/: bignum.c rsa.c
    ../src/ZC/: crc.c
